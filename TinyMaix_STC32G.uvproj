# Keil uVision project TinyMaix_STC32G.uvproj, settings and files
target TinyMaix_STC32G (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: TinyMaix +hex
  link misc: REMOVEUNUSED
  group user
    ./Sources/User/: putchar.c main.c
  group TinyMaix
    ./Sources/TinyMaix/: tm_layers.c tm_model.c tm_stat.c
